# Keil uVision project 1.uvprojx, settings and files
target Application (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group main
    ./: main.c app.c app.h main.h
  group GPIO
    ./: gpio.h gpio.c
  group UART
    ./: uart.h uart.c
  group NVIC
    ./: nvic.h nvic.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
